#Blacklist a bogus tag in upstream check
UPSTREAM_CHECK_GITTAGREGEX = "FILE(?P<pver>(?!6_23).+)"

SRCREV = "64503c1a161807380f4248c41d5d8d742893c819"
