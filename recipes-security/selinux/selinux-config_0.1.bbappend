DEFAULT_ENFORCING ??= "permissive"
EXTRA_OECONF = " --with-pcre --with-core-includes=${WORKSPACE}/system/core/include"
