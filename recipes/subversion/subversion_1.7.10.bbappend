FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"

SRC_URI += "\
           file://aupathfix.patch \
"
