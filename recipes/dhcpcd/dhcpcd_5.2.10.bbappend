FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"
SRC_URI += "\
file://dhcpcd_iface_info.patch"
