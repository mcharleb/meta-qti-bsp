SRC_URI = "${CAF_GIT}/platform/external/lttng-ust;protocol=git;branch=lttng/stable-2.6 \
           "

PR = "r2"
