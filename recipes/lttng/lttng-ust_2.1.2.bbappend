SRC_URI = "${CAF_GIT}/platform/external/lttng-ust;protocol=git \
           file://depends-liblttng-ust-tracepoin.patch \
           "

PR = "r1"
