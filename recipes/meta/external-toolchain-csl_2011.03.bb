packageid="package8739"
PV = "2011.03"
PR = "41"

SRC_URI[md5sum] = "63d93a9f7fe9ff007bc69adfadc7c4ab"
SRC_URI[sha256sum] = "4d4e9843aab1e92994901efce06f8b89f96a1b0c321750305c4058242d892d44"

# All the work's in the include file.
include external-toolchain-csl.inc
