packageid="package4571"
PV = "2009q1"
PR = "203"

SRC_URI[md5sum] = "1a6e88782f08b09a0e6cef545a1712ec"
SRC_URI[sha256sum] = "0004b59223f8151d1af211894e5c76c142e4c0e4529b531bf8f5565ec7f08ae6"

# All the work's in the include file...
include external-toolchain-csl.inc
