PRINC = "1"
FILESEXTRAPATHS_prepend := "${THISDIR}/netbase-4.47"
