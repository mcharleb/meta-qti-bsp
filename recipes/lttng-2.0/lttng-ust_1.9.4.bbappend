PRINC = "1"
FILESEXTRAPATHS := "${THISDIR}/${PN}"

SRC_URI += "file://depends-liblttng-ust-tracepoin.patch"
