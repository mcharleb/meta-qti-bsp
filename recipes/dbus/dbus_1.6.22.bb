include dbus.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "5e50717d0f355c33debe1e8ed6805655"
SRC_URI[sha256sum] = "9229f230c5e024b33ac7ce2e7767353ba996439ac79066a3ace6b072da1602a1"

