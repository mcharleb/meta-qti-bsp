# Set machine specific options
include ${MACHINE}-image.inc

# Build the image
require machine-image.bb
