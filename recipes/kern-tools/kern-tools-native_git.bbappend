PR = "r13"

SRC_URI = "${CAF_GIT}/platform/external/yocto-kernel-tools;protocol=git"
