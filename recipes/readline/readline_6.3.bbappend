#For GPL v3+ licensed portions:
#Copyright (c) 2014, Linux Foundation. All rights reserved.
#Linux Foundation chooses to take subject only to the GPLv3only
#license terms, and distributes only under these terms.

LICENSE = "GPLv3only"
LIC_FILES_CHKSUM = "file://COPYING;beginline=1;endline=621;md5=9eef91148a9b14ec7f9df333daebc746"

